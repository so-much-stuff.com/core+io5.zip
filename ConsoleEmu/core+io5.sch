# EAGLE board core+io5 (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$107  (via drill 0.61) (continued)
  Bottom 0.254: v111.12,72.86 119.38,72.86 120.01,73.5 IN5-6.13 | v111.12,82.39 111.12,83.02 101.59,83.02 100.96,82.39 97.78,82.39 v97.15,81.75
N$108
  Bottom 0.254: IC16.18 95.24,77.3 96.52,78.58 117.47,78.58 119.38,76.67 IN5-6.15
N$109  (via drill 0.61)
  Top 0.254: v107.31,60.16 107.31,62.7 IC15.13
  Bottom 0.254: v107.31,60.16 118.1,60.16 118.74,59.52 120.01,59.52 IN5-6.1
N$110  (via drill 0.61)
  Top 0.254: v106.04,79.84 106.04,72.86 105.41,72.22 105.41,70.95 106.04,70.32 106.04,65.24 105.41,64.61 IC15.14 | v121.28,79.21 121.28,62.06 120.64,61.43 IN5-6.3
  Bottom 0.254: v106.04,79.84 106.67,79.21 v121.28,79.21
N$111
  Bottom 0.254: IC15.17 97.78,63.34 99.05,62.06 113.02,62.06 113.66,62.7 118.1,62.7 119.38,63.97 IN5-6.5
N$112  (via drill 0.61)
  Top 0.254: v95.88,71.59 95.88,67.78 95.24,67.14 95.24,64.61 IC15.18 | v100.96,71.59 v100.96,81.11
  Bottom 0.254: v95.88,71.59 v100.96,71.59 | v100.96,81.11 111.75,81.11 112.39,80.48 121.28,80.48 122.55,79.21 122.55,66.51 120.64,66.51 IN5-6.7
N$113
  Bottom 0.254: IC8.19 17.77,101.44 16.5,100.16 13.33,100.16 11.43,102.07 OUT7-8.15
N$114
  Bottom 0.254: IC8.16 25.39,101.44 24.12,100.16 17.77,100.16 17.14,99.53 11.43,99.53 OUT7-8.13
N$115
  Bottom 0.254: IC8.15 28.57,100.8 26.03,98.26 12.7,98.26 11.43,96.99 OUT7-8.11
N$116  (via drill 0.61)
  Top 0.254: v12.06,103.97 12.06,95.08 11.43,94.45 OUT7-8.9
  Bottom 0.254: v12.06,103.97 35.55,103.97 36.19,103.34 IC8.12
N$117
  Bottom 0.254: IC8.2 17.77,93.81 16.5,92.55 12.06,92.55 11.43,93.18 10.16,93.18 8.89,94.45 OUT7-8.10
N$118  (via drill 0.61)
  Top 0.254: v26.03,99.53 26.03,95.72 IC8.5
  Bottom 0.254: v26.03,99.53 19.68,99.53 19.04,98.89 12.06,98.89 11.43,98.26 9.52,98.26 8.89,97.62 8.25,97.62 OUT7-8.12
N$119
  Bottom 0.254: IC8.6 27.93,95.08 26.66,96.36 14.6,96.36 13.97,95.72 7.62,95.72 6.98,96.36 6.98,99.53 7.62,99.53 OUT7-8.14
N$120
  Bottom 0.254: IC8.9 36.83,93.81 38.1,92.55 45.08,92.55 45.72,93.18 48.89,93.18 50.16,94.45 50.16,103.97 36.83,103.97 35.55,105.25 12.06,105.25 8.89,102.07 OUT7-8.16
N$121  (via drill 0.61)
  Top 0.254: v37.46,86.19 37.46,83.02 36.83,82.39 IC7.9 | v29.84,91.28 v29.84,86.19 | v18.41,91.91 17.14,93.18 17.14,95.72 16.5,96.36 16.5,100.16 17.14,100.8 17.14,103.34 16.5,103.97 13.33,103.97 12.06,105.25 10.16,105.25 10.16,103.34 9.52,102.7 9.52,101.44 8.89,100.8 7.62,100.8 6.98,100.16 6.98,92.55 7.62,91.91 OUT7-8.8
  Bottom 0.254: v29.84,86.19 v37.46,86.19 | v29.84,91.28 19.04,91.28 v18.41,91.91
N$122
  Bottom 0.254: IC7.6 27.93,81.11 26.66,79.84 7.62,79.84 5.08,82.39 5.08,89.37 7.62,89.37 OUT7-8.6
N$123  (via drill 0.61)
  Top 0.254: v26.03,85.56 26.03,83.02 IC7.5
  Bottom 0.254: v26.03,85.56 25.39,86.19 12.06,86.19 11.43,85.56 8.89,85.56 8.25,86.19 OUT7-8.4
N$124  (via drill 0.61)
  Top 0.254: v73.02,83.02 73.66,82.39 73.66,74.13 v73.02,73.5 | v64.13,73.5 62.86,74.77 61.59,74.77 60.32,73.5 60.32,60.8 61.59,59.52 61.59,57.62 IC26.15
  Bottom 0.254: v73.02,83.02 76.83,83.02 79.37,85.56 IC24.13 | v64.13,73.5 v73.02,73.5
N$125  (via drill 0.61)
  Top 0.254: v78.1,58.25 77.46,58.89 77.46,77.3 78.73,78.58 v78.73,83.02
  Bottom 0.254: v78.1,58.25 64.77,58.25 64.13,57.62 IC26.14 | v78.73,83.02 80,83.02 81.91,84.92 81.91,85.56 IC24.14
N$126  (via drill 0.61)
  Top 0.254: v66.67,59.52 66.67,57.62 IC26.13 | v78.73,59.52 78.1,59.52 78.1,76.67 v78.73,77.3 | v83.81,77.3 83.18,77.94 83.18,84.29 83.81,84.92 83.81,86.19 IC24.15
  Bottom 0.254: v66.67,59.52 67.3,58.89 77.46,58.89 78.1,59.52 v78.73,59.52 | v78.73,77.3 v83.81,77.3
N$127  (via drill 0.61)
  Top 0.254: v70.48,60.16 70.48,58.89 69.84,58.25 69.84,56.98 IC26.12 | v79.37,60.8 78.73,61.43 78.73,74.77 v79.37,75.4 | v86.99,74.77 85.72,76.03 85.72,83.02 86.99,84.29 86.99,85.56 IC24.16
  Bottom 0.254: v70.48,60.16 71.11,59.52 76.83,59.52 78.1,60.8 v79.37,60.8 | v79.37,75.4 85.72,75.4 86.35,74.77 v86.99,74.77
N$128  (via drill 0.61)
  Top 0.254: v88.26,60.16 88.26,81.11 89.53,82.39 89.53,85.56 IC24.17
  Bottom 0.254: v88.26,60.16 84.45,60.16 81.27,56.98 77.46,56.98 76.83,56.35 72.38,56.35 IC26.11
N$129
  Top 0.254: IC24.3 53.97,85.56 56.51,83.02 56.51,77.94 IC25.17
N$130
  Top 0.254: IC25.16 59.05,77.94 57.15,79.84 57.15,86.19 IC24.4
N$131
  Top 0.254: IC25.15 61.59,77.94 59.05,80.48 59.05,85.56 IC24.5
N$132
  Top 0.254: IC25.14 64.13,77.94 61.59,80.48 61.59,85.56 IC24.6
N$133
  Top 0.254: IC25.13 66.67,77.94 64.13,80.48 64.13,85.56 IC24.7
N$134
  Top 0.254: IC25.12 69.21,77.94 66.67,80.48 66.67,85.56 IC24.8
N$135
  Top 0.254: IC25.11 71.75,77.94 69.21,80.48 69.21,85.56 IC24.9
N$136  (via drill 0.61)
  Top 0.254: v99.05,87.47 99.05,85.56 98.42,84.92 98.42,84.29 97.78,83.66 97.78,83.02 97.15,83.02 95.88,84.29 95.88,85.56 95.24,86.19 IC24.19 | v129.53,88.1 129.53,86.83 130.17,86.19 130.17,60.16 129.53,59.52 v129.53,39.84
  Bottom 0.254: v99.05,87.47 99.69,88.1 123.19,88.1 123.82,87.47 128.9,87.47 v129.53,88.1 | v129.53,39.84 119.38,39.84 118.74,40.48 118.74,41.74 118.1,42.38 113.66,42.38 113.02,41.74 108.58,41.74 107.94,41.11 101.59,41.11 100.96,41.74 80.64,41.74 80,42.38 77.46,42.38 75.56,44.28 75.56,45.55 50.8,45.55 48.89,47.46 IC26.1
N$137  (via drill 0.61)
  Top 0.254: v52.7,81.75 52.7,88.1 51.43,89.37 51.43,100.8 IC24.39 | v49.53,81.75 50.16,81.75 50.16,74.13 48.89,72.86 48.89,70.32 IC25.1
  Bottom 0.254: v49.53,81.75 v52.7,81.75
N$138  (via drill 0.61)
  Top 0.254: v50.16,89.37 50.8,90 50.8,100.16 49.53,101.44 IC24.40 | v114.93,90 114.93,69.05 115.56,68.41 115.56,66.51 116.83,65.24 118.1,65.24 118.74,64.61 118.74,48.09 118.1,47.46 116.83,47.46 115.56,46.19 115.56,41.11 116.83,39.84 118.1,39.84 118.74,39.2 118.74,37.94 119.38,37.3 120.64,37.3 121.28,36.66 121.28,32.85 119.38,30.95 119.38,28.41 121.28,26.5 121.28,23.33 122.55,22.06 122.55,21.42 121.91,20.79 121.91,11.27 v122.55,10.63
  Bottom 0.254: v50.16,89.37 50.8,90 83.18,90 83.81,89.37 114.3,89.37 v114.93,90 | v122.55,10.63 160.01,10.63 163.82,14.44 169.54,14.44 173.35,10.63 174.62,10.63 IC27.9
N$140
  Top 0.254: IC27.8 177.16,8.09 177.79,8.09 C4.1
  Bottom 0.254: C4.1 179.06,8.09 180.34,8.09 182.88,10.63 R4.1 184.14,10.63 185.41,11.9 189.86,11.9 189.86,13.17 188.59,14.44 173.98,14.44 173.98,16.34 175.25,17.61 IC27.12
N$141
  Top 0.254: R3.1 181.6,18.25 182.88,18.25 R4.2
  Bottom 0.254: IC27.13 177.16,20.79 178.43,19.52 179.06,19.52 180.34,18.25 R3.1
N$142
  Bottom 0.254: IC27.11 177.16,15.71 185.41,15.71 C5.1
N$143
  Top 0.254: R10.1 167.63,3.01 166.37,4.28 166.37,4.92 R11.E
N$144
  Bottom 0.254: X1.4 142.87,15.08 143.5,14.44 148.59,14.44 149.22,13.81 X1.6
N$145
  Top 0.254: X1.8 144.78,13.17 146.04,13.17 X1.7
N$147
  Top 0.254: IC18.12 205.73,16.34 205.73,17.61 IC18.13 207,18.88 210.81,22.7 210.81,63.97 207.64,63.97 207,64.61 207,65.88 207.64,66.51 207.64,102.07 193.67,102.07 192.4,100.8 192.4,98.26 191.76,97.62 191.76,88.73 188.59,85.56 IC21.5
N$148
  Top 0.254: LED1.K 208.91,11.27 207.64,12.54 207.64,13.17 IC18.11
N$149
  Bottom 0.254: R12.1 179.06,18.25 180.34,16.98 192.4,16.98 197.48,11.9 202.56,11.9 205.1,9.36 209.54,9.36 210.81,10.63 LED1.A
N$150
  Top 0.254: R13.2 176.53,104.61 177.79,104.61 JP2.1 178.43,103.34 178.43,100.8 IC21.24
N$151
  Bottom 0.254: IC28.1 200.02,65.24 194.94,65.24 194.31,65.88 194.31,67.78 212.09,67.78 214.62,65.24 214.62,7.46 209.54,7.46 207.64,5.55 IC18.8
N$152
  Top 0.254: IC19.5 201.92,34.12 203.19,35.39 203.19,55.71 201.92,56.98 IC28.4
N$153
  Top 0.254: IC20.7 154.94,25.23 156.2,25.23 IC20.8
N$154
  Bottom 0.254: C7.1 147.31,20.79 165.73,20.79 167.63,18.88 IC27.3
N$155
  Top 0.254: IC20.5 149.85,26.5 154.3,30.95 158.75,30.95 158.75,33.49 C9.2
N$156
  Bottom 0.254: IC20.4 147.31,26.5 149.22,28.41 158.75,28.41 C9.1
N$157
  Bottom 0.254: C8.2 137.16,30.95 140.33,27.77 142.23,27.77 143.5,26.5 IC20.3
N$158
  Top 0.254: C8.1 137.16,25.87 138.42,25.87 IC20.1
N$159
  Bottom 0.254: C11.1 147.31,23.33 147.95,23.96 149.85,23.96 151.12,25.23 IC20.6
N$160
  Top 0.254: C10.2 139.69,23.33 140.97,24.6 140.97,25.23 IC20.2
NMI\  (via drill 0.61)
  Top 0.254: IC17.6 179.7,61.43 179.06,61.43 R6.1 | v193.03,62.7 193.67,63.34 193.67,83.02 IC21.7
  Bottom 0.254: v193.03,62.7 186.05,62.7 184.78,61.43 182.24,61.43 IC17.6
OUT00  (via drill 0.61)
  Top 0.254: v41.91,13.17 41.91,27.77 v41.27,28.41
  Bottom 0.254: v41.91,13.17 39.37,13.17 IC1.11 | v41.27,28.41 45.72,28.41 IC10.1
OUT01
  Bottom 0.254: IC2.11 39.37,26.5 46.98,26.5 48.26,27.77 IC10.2
OUT02  (via drill 0.61)
  Top 0.254: v52.7,37.3 52.07,36.66 52.07,29.04 IC10.3
  Bottom 0.254: v52.7,37.3 38.73,37.3 IC3.11
OUT03  (via drill 0.61)
  Top 0.254: v55.24,39.84 54.61,39.2 54.61,29.04 IC10.4 | v42.54,39.84 41.91,40.48 v41.91,50
  Bottom 0.254: v55.24,39.84 54.61,39.2 45.08,39.2 44.45,39.84 v42.54,39.84 | v41.91,50 38.73,50 IC4.11
OUT04  (via drill 0.61)
  Top 0.254: v57.78,41.11 57.15,40.48 57.15,38.57 55.88,37.3 55.88,29.04 IC10.5 | v43.18,41.11 42.54,41.11 42.54,49.37 43.18,50 43.18,55.71 42.54,56.35 v42.54,63.97
  Bottom 0.254: v43.18,41.11 v57.78,41.11 | v42.54,63.97 39.37,63.97 IC5.11
OUT05  (via drill 0.61)
  Top 0.254: v43.81,77.94 45.08,76.67 45.08,74.77 46.35,73.5 45.08,72.22 45.08,59.52 47.62,56.98 v47.62,33.49 | v59.05,33.49 59.05,29.68 IC10.6
  Bottom 0.254: v43.81,77.94 38.73,77.94 IC6.11 | v47.62,33.49 48.26,34.12 58.41,34.12 v59.05,33.49
OUT06  (via drill 0.61)
  Top 0.254: v38.73,84.29 38.73,88.1 IC7.11 | v73.02,84.29 74.29,83.02 74.29,52.54 73.02,51.27 v73.02,40.48 | v62.86,40.48 62.23,39.84 62.23,29.04 IC10.7
  Bottom 0.254: v38.73,84.29 39.37,83.66 41.27,83.66 41.91,84.29 v73.02,84.29 | v73.02,40.48 72.38,41.11 63.5,41.11 v62.86,40.48
OUT07
  Top 0.254: IC10.8 64.13,27.14 62.86,25.87 62.86,9.36 60.32,6.82 60.32,4.28 57.78,1.74 40,1.74 40,28.41 40.64,29.04 40.64,51.27 42.54,53.17 42.54,55.08 41.91,55.71 41.91,63.34 41.27,63.97 41.27,72.86 43.18,74.77 43.18,76.03 42.54,76.67 42.54,79.84 43.18,80.48 43.18,96.36 38.73,100.8 IC8.11
PIA-A0
  Top 0.254: 93.34,15.71 93.34,8.09 92.07,6.82 IC11.2 | 93.34,15.71 92.07,16.98 IC12.2 | 93.34,28.41 92.07,29.68 IC13.2 | 93.34,15.71 93.34,28.41 | 93.34,41.11 92.07,42.38 IC14.2 | 93.34,28.41 93.34,41.11 | 93.34,53.81 92.07,55.08 IC15.2 | 93.34,41.11 93.34,53.81 | 93.34,53.81 93.34,66.51 92.07,67.78 IC16.2 | IC1.3 20.95,6.82 22.22,8.09 22.22,14.44 20.95,15.71 20.95,16.98 IC2.3 20.95,19.52 22.22,20.79 22.22,27.14 21.58,27.77 21.58,30.31 IC3.3 20.95,32.22 22.22,33.49 22.22,39.84 21.58,40.48 21.58,43.02 IC4.3 20.95,44.92 22.22,46.19 22.22,52.54 21.58,53.17 21.58,55.71 IC5.3 20.95,57.62 22.22,58.89 22.22,65.88 20.95,67.14 20.95,67.78 IC6.3 20.95,70.32 22.22,71.59 22.22,77.94 21.58,78.58 21.58,79.84 20.95,80.48 IC7.3 20.95,83.02 22.22,84.29 22.22,90.64 21.58,91.28 21.58,93.81 IC8.3 | IC25.2 51.43,67.78 50.16,66.51 50.16,63.34 48.89,62.06 SV9.1
  Bottom 0.254: SV9.1 48.26,61.43 33.02,61.43 32.38,60.8 31.74,60.8 29.84,62.7 29.84,66.51 23.49,66.51 21.58,68.41 IC6.3 | IC12.2 91.44,17.61 90.16,16.34 88.26,16.34 86.99,17.61 62.23,17.61 55.24,10.63 32.38,10.63 29.84,8.09 29.84,3.64 22.86,3.64 21.58,4.92 IC1.3
PIA-A1  (via drill 0.61)
  Top 0.254: IC11.5 99.69,6.82 99.69,8.73 100.96,10 100.96,14.44 100.32,15.08 100.32,17.61 IC12.5 100.32,18.88 100.32,20.15 100.96,20.79 100.96,27.14 100.32,27.77 100.32,30.31 IC13.5 100.32,31.58 100.32,32.85 100.96,33.49 100.96,39.84 | 100.96,39.84 100.32,40.48 100.32,43.02 IC14.5 100.32,44.28 100.32,45.55 100.96,46.19 100.96,52.54 100.32,53.17 100.32,55.71 IC15.5 100.32,56.98 100.32,58.25 100.96,58.89 100.96,65.24 100.32,65.88 100.32,68.41 IC16.5 | v48.89,66.51 48.89,64.61 SV9.2 | 24.76,16.98 24.12,17.61 IC2.4 | 24.76,16.98 24.76,10 23.49,8.73 23.49,6.82 IC1.4 | 24.76,29.68 24.12,30.31 IC3.4 | 24.76,16.98 24.76,29.68 | 24.76,42.38 24.12,43.02 IC4.4 | 24.76,29.68 24.76,42.38 | 24.76,55.08 24.12,55.71 IC5.4 | 24.76,42.38 24.76,55.08 | 24.76,67.78 24.12,68.41 IC6.4 | 24.76,55.08 24.76,67.78 | 24.76,80.48 24.12,81.11 IC7.4 | 24.76,67.78 24.76,80.48 | 24.76,80.48 24.76,93.18 24.12,93.81 IC8.4 | v100.96,40.48 100.96,39.84
  Bottom 0.254: IC25.3 53.97,67.78 52.7,66.51 v48.89,66.51 48.26,65.88 40.64,65.88 40,66.51 35.55,66.51 34.92,67.14 24.12,67.14 23.49,67.78 IC6.4 | v100.96,40.48 100.32,41.11 80,41.11 79.37,41.74 58.41,41.74 57.78,42.38 57.15,41.74 43.81,41.74 43.18,42.38 40,42.38 39.37,41.74 38.1,41.74 37.46,42.38 36.83,41.74 24.12,41.74 23.49,42.38 IC4.4
PIA-A2  (via drill 0.61)
  Top 0.254: IC1.7 31.74,6.18 32.38,6.82 v32.38,9.36 32.38,15.08 31.11,16.34 31.11,16.98 IC2.7 31.74,18.88 31.74,23.96 32.38,24.6 32.38,27.77 31.11,29.04 31.11,29.68 IC3.7 31.74,31.58 31.74,36.66 32.38,37.3 32.38,40.48 31.11,41.74 31.11,42.38 IC4.7 31.74,44.28 31.74,49.37 32.38,50 32.38,53.17 31.11,54.45 31.11,55.08 IC5.7 31.74,56.98 31.74,62.06 32.38,62.7 | v76.83,9.36 v76.83,6.82 | IC12.6 102.86,18.88 102.86,23.96 103.5,24.6 103.5,27.14 102.86,27.77 102.86,28.41 102.23,29.04 102.23,29.68 IC13.6 102.86,31.58 102.86,36.66 103.5,37.3 103.5,39.84 102.86,40.48 102.86,41.11 102.23,41.74 102.23,42.38 IC14.6 102.86,44.28 102.86,49.37 103.5,50 103.5,52.54 102.86,53.17 102.86,53.81 102.23,54.45 102.23,55.08 IC15.6 102.86,56.98 102.86,59.52 | 102.86,59.52 102.86,62.06 103.5,62.7 103.5,65.24 102.86,65.88 102.86,68.41 IC16.6 | v55.24,62.7 55.24,65.24 55.88,65.88 55.88,68.41 IC25.4 | IC8.7 31.11,93.18 31.11,92.55 32.38,91.28 32.38,88.1 31.74,87.47 31.74,82.39 IC7.7 31.74,81.11 31.74,78.58 32.38,77.94 32.38,71.59 31.74,70.95 31.74,69.69 IC6.7 31.11,67.78 31.11,67.14 32.38,65.88 32.38,62.7 | 32.38,62.7 v32.38,62.06 | v103.5,59.52 102.86,59.52 | v52.7,54.45 52.7,57.62 51.43,58.89 51.43,60.8 SV9.3
  Bottom 0.254: v76.83,6.82 77.46,6.18 87.62,6.18 88.89,7.46 95.24,7.46 95.88,6.82 96.52,7.46 101.59,7.46 102.23,6.82 IC11.6 | v76.83,9.36 76.19,8.73 38.1,8.73 37.46,9.36 v32.38,9.36 | v55.24,62.7 52.7,62.7 52.07,62.06 51.43,62.06 | 51.43,62.06 SV9.3 51.43,62.06 | 51.43,62.06 50.16,62.06 49.53,62.7 47.62,62.7 46.98,62.06 v32.38,62.06 | v103.5,59.52 103.5,58.89 94.61,58.89 93.97,58.25 88.26,58.25 86.99,56.98 82.55,56.98 81.91,56.35 79.37,56.35 77.46,54.45 74.29,54.45 73.66,53.81 57.15,53.81 56.51,54.45 v52.7,54.45
PIA-A3  (via drill 0.61)
  Top 0.254: IC15.9 109.85,57.62 109.85,61.43 111.12,62.7 111.12,65.24 109.85,66.51 109.85,67.78 IC16.9 109.21,69.69 109.21,74.77 108.58,75.4 108.58,83.02 104.77,86.83 103.5,86.83 v103.5,79.84 | v59.05,65.88 59.05,67.78 IC25.5 59.69,69.69 59.69,74.13 v60.32,74.77 | IC14.9 110.48,43.02 110.48,40.48 111.12,39.84 111.12,37.3 109.85,36.03 109.85,32.22 IC13.9 110.48,30.31 110.48,27.77 111.12,27.14 111.12,21.42 109.85,20.15 109.85,19.52 IC12.9 110.48,17.61 110.48,15.08 111.12,14.44 111.12,6.82 110.48,6.18 IC11.9 109.21,4.92 106.67,2.38 104.13,2.38 104.13,3.64 103.5,4.28 103.5,6.82 104.13,7.46 v104.13,9.36 | IC8.8 34.29,93.81 34.29,91.28 34.92,90.64 34.92,88.1 34.29,87.47 34.29,82.39 IC7.8 33.65,80.48 33.65,79.84 34.29,79.21 34.29,78.58 34.92,77.94 34.92,75.4 34.29,74.77 34.29,69.69 IC6.8 34.29,68.41 34.29,65.88 34.92,65.24 | IC1.8 34.29,6.18 34.29,8.09 34.92,8.73 34.92,14.44 34.29,15.08 34.29,15.71 33.65,16.34 33.65,16.98 IC2.8 34.29,18.88 34.29,23.96 34.92,24.6 34.92,27.14 34.29,27.77 34.29,28.41 33.65,29.04 33.65,29.68 IC3.8 34.29,31.58 34.29,36.66 34.92,37.3 | 34.92,37.3 34.92,39.84 34.29,40.48 34.29,41.11 33.65,41.74 33.65,42.38 IC4.8 34.29,44.28 34.29,49.37 34.92,50 34.92,52.54 34.29,53.17 34.29,53.81 33.65,54.45 33.65,55.08 IC5.8 34.29,56.98 34.29,59.52 34.92,60.16 34.92,65.24 | v77.46,11.9 78.1,12.54 78.1,26.5 77.46,27.14 77.46,29.68 76.83,30.31 76.83,34.76 v76.19,35.39 | 34.92,37.3 v34.92,35.39 | 34.92,65.24 v34.92,65.88
  Bottom 0.254: v59.05,65.88 58.41,65.24 52.07,65.24 | 52.07,65.24 51.43,64.61 SV9.4 | v103.5,79.84 102.86,79.21 76.83,79.21 72.38,74.77 v60.32,74.77 | v104.13,9.36 97.15,9.36 95.88,10.63 95.24,10.63 94.61,10 84.45,10 82.55,11.9 v77.46,11.9 | v34.92,35.39 v76.19,35.39 | 52.07,65.24 40,65.24 39.37,65.88 v34.92,65.88
PIA-A4  (via drill 0.61)
  Top 0.254: IC15.12 109.21,63.34 109.21,58.25 108.58,57.62 108.58,55.08 109.85,53.81 109.85,52.54 IC14.12 109.21,50.63 109.21,48.73 108.58,48.09 108.58,42.38 109.85,41.11 109.85,39.84 IC13.12 109.21,37.94 109.21,32.85 108.58,32.22 108.58,29.68 109.85,28.41 109.85,27.14 IC12.12 109.85,24.6 109.85,23.96 110.48,23.33 110.48,22.06 108.58,20.15 108.58,16.98 109.85,15.71 109.85,14.44 IC11.12 | v53.97,66.51 52.7,65.24 52.7,62.06 53.34,61.43 SV9.5 | IC1.13 33.65,14.44 33.65,15.08 32.38,16.34 32.38,19.52 33.65,20.79 33.65,24.6 IC2.13 33.65,27.14 33.65,27.77 32.38,29.04 32.38,32.22 33.65,33.49 33.65,37.3 IC3.13 33.65,39.84 33.65,40.48 32.38,41.74 32.38,44.92 33.65,46.19 33.65,50 IC4.13 33.65,52.54 33.65,53.17 32.38,54.45 32.38,57.62 33.65,58.89 v33.65,60.16 33.65,62.7 IC5.13 33.65,65.24 33.65,65.88 32.38,67.14 32.38,70.32 33.65,71.59 33.65,75.4 IC6.13 33.65,77.94 33.65,78.58 32.38,79.84 32.38,83.02 33.65,84.29 33.65,88.1 IC7.13 33.65,90.64 33.65,91.28 32.38,92.55 32.38,95.72 33.65,96.99 33.65,100.8 IC8.13 | v109.85,90.64 109.21,90 109.21,77.3 IC16.12 | v125.72,65.24 125.09,65.88 125.09,75.4 125.72,76.03 125.72,77.3 126.36,77.94 126.36,85.56 126.99,86.19 126.99,90 v127.63,90.64
  Bottom 0.254: v53.97,66.51 54.61,67.14 60.96,67.14 61.59,67.78 IC25.6 | v33.65,60.16 53.34,60.16 53.97,60.8 SV9.5 | 109.21,91.28 v109.85,90.64 | 109.21,91.28 80.64,91.28 80,90.64 40,90.64 39.37,91.28 34.29,91.28 33.65,90.64 IC7.13 | v125.72,65.24 116.83,65.24 116.2,65.88 109.85,65.88 109.85,65.24 IC15.12 | v127.63,90.64 126.99,91.28 109.21,91.28
PIA-A5  (via drill 0.61)
  Top 0.254: IC1.14 31.11,14.44 31.11,15.08 29.84,16.34 29.84,19.52 31.11,20.79 31.11,24.6 IC2.14 31.11,27.14 31.11,27.77 29.84,29.04 29.84,32.22 31.11,33.49 31.11,37.3 IC3.14 31.11,39.84 31.11,40.48 29.84,41.74 29.84,44.92 31.11,46.19 31.11,50 IC4.14 31.11,52.54 31.11,53.17 29.84,54.45 29.84,57.62 31.11,58.89 31.11,62.7 IC5.14 31.11,65.24 31.11,65.88 29.84,67.14 29.84,70.32 31.11,71.59 v31.11,72.22 31.11,75.4 IC6.14 31.11,77.94 31.11,78.58 29.84,79.84 29.84,83.02 31.11,84.29 31.11,88.1 IC7.14 31.11,90.64 31.11,91.28 29.84,92.55 29.84,95.72 31.11,96.99 31.11,100.8 IC8.14 | IC11.15 102.23,14.44 102.23,15.08 100.96,16.34 100.96,19.52 102.23,20.79 102.23,24.6 IC12.15 102.23,27.14 102.23,27.77 100.96,29.04 100.96,32.22 102.23,33.49 102.23,37.3 IC13.15 102.23,39.84 102.23,40.48 100.96,41.74 100.96,44.92 102.23,46.19 102.23,50 IC14.15 102.23,52.54 102.23,53.17 100.96,54.45 100.96,57.62 102.23,58.89 102.23,62.7 IC15.15 102.23,65.24 102.23,65.88 100.96,67.14 100.96,70.32 102.23,71.59 102.23,75.4 IC16.15 | v55.24,70.95 55.24,66.51 54.61,65.88 54.61,63.97 SV9.6
  Bottom 0.254: IC15.15 102.23,65.24 100.96,66.51 94.61,66.51 93.97,67.14 88.26,67.14 87.62,67.78 86.99,67.78 86.35,67.14 64.77,67.14 64.13,67.78 IC25.7 64.13,70.32 63.5,70.95 v55.24,70.95 53.34,72.86 45.72,72.86 45.08,72.22 v31.11,72.22
PIA-A6  (via drill 0.61)
  Top 0.254: IC8.17 23.49,100.8 23.49,98.26 22.22,96.99 22.22,91.91 22.86,91.28 22.86,90 IC7.17 22.86,88.73 22.86,83.66 22.22,83.02 22.22,79.21 22.86,78.58 22.86,77.3 IC6.17 22.86,76.03 22.86,70.95 22.22,70.32 22.22,67.14 22.86,66.51 22.86,64.61 IC5.17 22.86,63.34 22.86,58.25 22.22,57.62 22.22,53.81 22.86,53.17 22.86,51.91 IC4.17 22.86,50.63 22.86,45.55 22.22,44.92 22.22,41.11 22.86,40.48 22.86,39.2 IC3.17 22.86,37.94 22.86,32.85 22.22,32.22 22.22,28.41 22.86,27.77 22.86,26.5 IC2.17 22.86,25.23 22.86,20.15 22.22,19.52 22.22,15.71 22.86,15.08 22.86,13.81 IC1.17 | v65.4,62.7 65.4,67.78 66.03,68.41 IC25.8 67.3,68.41 v70.48,65.24 | IC16.16 99.05,76.03 99.05,70.95 98.42,70.32 98.42,65.24 99.05,64.61 IC15.16 99.69,62.7 99.69,60.16 98.42,58.89 98.42,54.45 99.69,53.17 99.69,52.54 IC14.16 99.69,50 99.69,47.46 98.42,46.19 98.42,39.84 99.05,39.2 IC13.16 99.69,37.3 99.69,34.76 98.42,33.49 98.42,27.14 99.05,26.5 IC12.16 99.69,24.6 99.69,22.06 98.42,20.79 98.42,15.71 99.05,15.08 99.05,13.81 IC11.16 | v37.46,15.08 v37.46,8.09 | v95.88,9.36 v95.88,15.08
  Bottom 0.254: v65.4,62.7 57.78,62.7 57.15,62.06 56.51,62.06 SV9.7 | v70.48,65.24 71.11,65.88 86.35,65.88 86.99,65.24 87.62,65.24 88.26,65.88 99.05,65.88 99.69,65.24 IC15.16 | v37.46,15.08 24.12,15.08 23.49,14.44 IC1.17 | v37.46,8.09 80.64,8.09 81.91,9.36 v95.88,9.36 | v95.88,15.08 99.05,15.08 99.69,14.44 IC11.16
PIA-A7  (via drill 0.61)
  Top 0.254: IC8.18 20.95,100.8 20.95,96.99 19.68,95.72 19.68,93.18 20.95,91.91 20.95,90.64 IC7.18 20.95,88.1 20.95,84.29 19.68,83.02 19.68,77.94 20.31,77.3 IC6.18 20.95,75.4 20.95,71.59 19.68,70.32 19.68,67.14 20.95,65.88 20.95,65.24 IC5.18 20.95,62.7 20.95,58.89 19.68,57.62 19.68,55.08 20.95,53.81 20.95,52.54 IC4.18 20.95,50 20.95,46.19 19.68,44.92 19.68,42.38 20.95,41.11 20.95,39.84 IC3.18 20.95,37.3 20.95,33.49 19.68,32.22 19.68,29.68 20.95,28.41 20.95,27.14 IC2.18 20.95,24.6 20.95,20.79 19.68,19.52 19.68,14.44 20.31,13.81 IC1.18 | IC11.19 91.44,13.81 90.8,14.44 90.8,22.06 92.07,23.33 92.07,24.6 IC12.19 91.44,26.5 90.8,27.14 90.8,32.85 92.07,34.12 92.07,37.3 IC13.19 91.44,39.2 90.8,39.84 90.8,45.55 92.07,46.82 92.07,50 IC14.19 91.44,51.91 90.8,52.54 90.8,58.25 92.07,59.52 92.07,62.7 IC15.19 91.44,64.61 90.8,65.24 v90.8,70.95 92.07,72.22 92.07,75.4 IC16.19 | v57.78,72.22 57.78,67.78 56.51,66.51 56.51,64.61 SV9.8 | v69.21,72.22 69.21,70.32 IC25.9
  Bottom 0.254: v90.8,70.95 88.89,70.95 88.26,70.32 83.18,70.32 82.55,70.95 69.84,70.95 69.21,70.32 IC25.9 | v57.78,72.22 58.41,72.86 62.23,72.86 62.86,72.22 v69.21,72.22 | IC3.18 20.95,39.84 21.58,40.48 36.83,40.48 37.46,39.84 37.46,36.66 39.37,36.66 40,36.03 75.56,36.03 76.19,36.66 91.44,36.66 92.07,37.3 IC13.19
PIA-B0  (via drill 0.61)
  Top 0.254: IC9.23 48.89,22.06 48.89,23.96 47.62,25.23 47.62,29.68 48.89,30.95 48.89,42.38 IC10.23 49.53,44.28 49.53,46.82 50.8,48.09 IC26.2 | v64.13,58.89 64.13,60.8 SV9.13 | v60.32,51.91 v60.32,58.25
  Bottom 0.254: v64.13,58.89 63.5,58.25 v60.32,58.25 | v60.32,51.91 59.69,51.27 56.51,51.27 55.88,50.63 52.07,50.63 51.43,50 IC26.2
PIA-B1  (via drill 0.61)
  Top 0.254: IC9.22 51.43,22.06 51.43,23.96 50.16,25.23 50.16,29.68 51.43,30.95 51.43,42.38 IC10.22 52.07,44.28 52.07,46.82 53.34,48.09 IC26.3 53.97,50 v53.97,52.54 | v62.86,73.5 62.86,67.14 64.13,65.88 64.13,64.61 SV9.14 | v45.08,73.5 44.45,72.86 44.45,56.98 45.08,56.35 v45.08,52.54
  Bottom 0.254: v45.08,73.5 v62.86,73.5 | v53.97,52.54 v45.08,52.54
PIA-B2  (via drill 0.61)
  Top 0.254: IC9.21 53.97,22.06 53.97,23.96 52.7,25.23 52.7,29.68 53.97,30.95 53.97,42.38 IC10.21 54.61,44.28 54.61,46.82 55.88,48.09 IC26.4 | v65.4,50.63 65.4,60.8 66.03,61.43 SV9.15
  Bottom 0.254: v65.4,50.63 57.15,50.63 56.51,50 IC26.4
PIA-B3  (via drill 0.61)
  Top 0.254: IC26.5 59.05,47.46 59.05,46.19 57.15,44.28 IC10.20 56.51,42.38 56.51,39.84 55.24,38.57 55.24,22.06 55.88,21.42 IC9.20 | v97.78,60.16 v95.88,62.06 | v106.04,60.16 106.04,50 103.5,47.46 103.5,42.38 106.04,39.84 v106.04,34.76
  Bottom 0.254: v95.88,62.06 83.81,62.06 83.18,62.7 67.3,62.7 66.67,63.34 SV9.16 | v97.78,60.16 97.78,60.8 105.41,60.8 v106.04,60.16 | v106.04,34.76 85.72,34.76 85.08,34.12 74.92,34.12 74.29,34.76 40,34.76 37.46,32.22 37.46,23.96 48.89,23.96 50.16,22.7 55.88,22.7 56.51,22.06 IC9.20
PIA-B4  (via drill 0.61)
  Top 0.254: IC9.18 61.59,22.06 61.59,23.96 60.32,25.23 60.32,29.68 61.59,30.95 61.59,40.48 60.32,41.74 60.32,47.46 60.96,48.09 IC26.6 61.59,50 v61.59,51.91 | v67.94,51.91 67.94,60.8 68.57,61.43 SV9.17
  Bottom 0.254: v61.59,51.91 v67.94,51.91
PIA-B5  (via drill 0.61)
  Top 0.254: IC10.18 62.23,44.28 64.13,46.19 64.13,47.46 IC26.7 64.13,50 64.13,51.91 62.86,53.17 v62.86,65.24
  Bottom 0.254: v62.86,65.24 68.57,65.24 69.21,64.61 SV9.18
PIA-B6
  Top 0.254: IC26.8 67.3,48.09 68.57,46.82 70.48,46.82 70.48,57.62 71.75,58.89 71.75,60.8 SV9.19
PIA-B7  (via drill 0.61)
  Top 0.254: v72.38,51.91 73.66,53.17 73.66,62.7 72.38,63.97 SV9.20 | v69.21,51.91 69.21,50 IC26.9
  Bottom 0.254: v69.21,51.91 v72.38,51.91
R/W\  (via drill 0.61)
  Top 0.254: v213.35,58.89 214.62,60.16 214.62,98.26 v213.35,99.53 | v100.32,86.83 v100.32,102.07 | v130.81,59.52 v130.81,86.83 v130.81,105.25 | v206.37,91.28 206.37,98.26 IC21.13 | v172.08,91.91 v172.08,105.25
  Bottom 0.254: v213.35,58.89 197.48,58.89 IC17.34 | v213.35,99.53 207,99.53 IC21.13 | v100.32,102.07 97.78,102.07 IC24.21 | v100.32,86.83 100.32,87.47 114.93,87.47 116.2,86.19 118.1,86.19 118.74,86.83 v130.81,86.83 | v130.81,59.52 139.69,59.52 140.33,60.16 IC22.27 | v206.37,91.28 201.29,91.28 200.66,91.91 198.12,91.91 197.48,92.55 172.72,92.55 v172.08,91.91 | v172.08,105.25 171.44,105.88 131.44,105.88 v130.81,105.25
RST\  (via drill 0.61)
  Top 0.254: v192.4,8.09 192.4,20.79 190.5,22.7 v190.5,44.92 | v187.32,44.92 187.32,54.45 188.59,55.71 188.59,63.97 187.32,65.24 v187.32,74.13 | v119.38,98.26 120.01,97.62 v120.01,85.56 | v144.14,84.29 144.78,84.92 149.22,84.92 v149.22,75.4
  Bottom 0.254: v192.4,8.09 197.48,8.09 IC18.6 | v187.32,44.92 v190.5,44.92 | IC17.40 194.94,74.13 v187.32,74.13 183.51,74.13 182.24,75.4 v149.22,75.4 | v119.38,98.26 118.74,97.62 105.41,97.62 104.77,98.26 76.19,98.26 74.29,100.16 64.77,100.16 64.13,100.8 IC24.34 | v120.01,85.56 120.64,86.19 130.17,86.19 130.81,85.56 142.87,85.56 v144.14,84.29
RX
  Top 0.254: IC20.12 149.85,32.85 151.12,31.58 158.11,31.58 158.11,37.94 161.28,41.11 162.56,41.11 162.56,12.54 161.92,11.9 161.92,6.82 167,1.74 179.7,1.74 179.7,24.6 179.06,25.23 179.06,40.48 175.89,43.65 175.89,53.17 175.25,53.81 175.25,63.34 179.7,67.78 184.14,67.78 184.14,75.4 184.78,76.03 184.78,80.48 181.6,83.66 IC21.2
RXD
  Top 0.254: IC20.13 146.68,32.22 145.41,30.95 145.41,16.34 X1.3
TX  (via drill 0.61)
  Top 0.254: v151.76,58.25 151.12,57.62 151.12,48.09 151.76,47.46 151.76,34.76 IC20.11 | v151.76,68.41 151.12,69.05 151.12,78.58 v151.76,79.21 | v191.13,81.11 191.13,83.02 IC21.6
  Bottom 0.254: v151.76,68.41 v151.76,58.25 | v151.76,79.21 158.11,79.21 158.75,79.84 174.62,79.84 175.89,81.11 v191.13,81.11
TXD
  Top 0.254: IC20.14 144.78,34.12 146.04,35.39 147.95,35.39 147.95,16.34 X1.2
VCC  (via drill 0.61)
  Top 0.508: v81.91,25.87 81.91,21.42 BYP17.1 81.91,20.15 81.91,18.25 83.18,16.98 v83.18,13.17 | BYP12.1 86.99,26.5 86.99,28.41 88.26,29.68 88.26,34.76 86.99,36.03 86.99,37.94 BYP13.1 86.99,39.2 86.99,41.11 88.26,42.38 88.26,45.55 88.89,46.19 88.89,46.82 89.53,47.46 89.53,50 IC14.20 | SV9.11 61.59,62.06 61.59,63.34 SV9.12 61.59,64.61 v61.59,66.51 | BYP14.1 86.99,51.91 86.99,54.45 85.72,55.71 85.72,63.34 86.35,63.97 BYP15.1 86.99,64.61 v86.99,66.51 | BYP24.1 46.35,91.28 46.35,88.73 45.08,87.47 45.08,81.11 46.35,79.84 46.35,77.3 BYP25.1 | BYP9.1 43.81,21.42 43.81,29.04 45.08,30.31 45.08,37.94 46.35,39.2 46.35,42.38 IC10.24 | BYP10.1 43.81,44.28 v43.81,46.19 v43.81,56.35 v43.81,76.67 | BYP1.1 13.33,13.81 13.33,16.34 14.6,17.61 14.6,21.42 15.87,22.7 15.87,24.6 IC2.20 | BYP2.1 13.33,26.5 13.33,27.14 14.6,28.41 14.6,32.85 15.87,34.12 15.87,37.3 IC3.20 15.24,39.2 14.6,39.84 14.6,46.82 15.87,48.09 | BYP4.1 13.33,51.91 13.33,54.45 14.6,55.71 14.6,58.25 15.87,59.52 15.87,62.7 IC5.20 | IC6.20 15.87,75.4 15.87,73.5 14.6,72.22 14.6,66.51 13.33,65.24 13.33,64.61 BYP5.1 | IC7.20 15.87,88.1 15.87,84.92 14.6,83.66 14.6,79.21 13.33,77.94 13.33,77.3 BYP6.1 | IC8.20 15.87,100.8 15.87,96.99 14.6,95.72 14.6,91.91 13.33,90.64 13.33,90 BYP7.1 | 15.87,48.09 15.87,50 IC4.20 | v15.87,46.82 15.87,48.09 | v48.89,58.89 48.89,57.62 IC26.20 | R5.2 191.13,78.58 191.13,77.3 R8.2 191.13,76.03 v191.13,63.97 | v196.21,79.21 196.21,83.02 IC21.8 | v175.89,86.19 175.89,88.73 BYP21.1 | v179.7,89.37 179.7,100.8 180.34,101.44 180.34,103.97 JP2.2 | v178.43,56.35 178.43,54.45 R6.2 | IC17.35 196.21,62.06 196.21,63.34 IC17.36
  Top 0.508: v198.75,61.43 198.75,54.45 BYP28.1 | v186.05,61.43 v186.05,56.35 | v205.1,65.24 v205.1,63.97 205.1,48.73 205.73,48.09 205.73,44.28 v205.1,43.65 205.1,33.49 206.37,32.22 v206.37,29.68 v206.37,23.33 206.37,21.42 IC18.14 | v188.59,10.63 v188.59,13.17 188.59,17.61 R2.2 188.59,18.88 188.59,20.15 R1.2 188.59,21.42 v188.59,22.7 | v97.15,84.29 97.15,85.56 IC24.20 97.15,88.1 97.15,90.64 94.61,93.18 94.61,100.8 IC24.22 | v89.53,80.48 89.53,77.94 IC16.20 | v99.69,80.48 99.69,83.66 R14.2 | v114.93,13.17 v114.93,25.87 v114.93,38.57 114.93,42.38 113.66,43.65 113.66,46.19 112.39,47.46 112.39,50 IC14.11 | v114.93,51.27 v114.93,63.97 114.93,67.78 114.3,68.41 114.3,74.77 113.02,76.03 IC16.11 112.39,77.94 v112.39,81.75 v112.39,84.29 | R7.2 140.33,83.66 140.33,83.02 IC23.27 | IC22.28 137.79,62.7 137.79,65.24 IC23.1 137.79,67.78 137.79,80.48 IC23.28 | v173.35,5.55 v173.35,13.17 v173.35,23.33 | v178.43,13.17 178.43,11.27 R12.2 | BYP20.1 133.98,21.42 133.98,22.7 C10.1 | v139.06,36.66 139.06,34.76 IC20.16 | v172.08,23.33 v172.08,36.66 | BYP27.1 175.89,25.23 175.89,23.96 IC27.14 | v136.52,23.33 135.88,23.96 135.88,24.6 135.25,25.23 v135.25,33.49 | v133.98,36.66 133.98,59.52 134.62,60.16 134.62,61.43 BYP22.1 | v48.89,80.48 48.89,77.94 IC25.20
  Bottom 0.508: BYP13.1 87.62,38.57 88.89,38.57 IC13.20 | IC11.20 88.89,13.17 87.62,13.17 BYP11.1 86.35,13.17 v83.18,13.17 | IC12.20 88.89,25.87 87.62,25.87 BYP12.1 86.35,25.87 v81.91,25.87 | BYP14.1 87.62,51.27 88.89,51.27 IC14.20 | BYP15.1 87.62,63.97 88.89,63.97 IC15.20 | v61.59,66.51 v86.99,66.51 | IC25.20 48.26,76.67 46.98,76.67 BYP25.1 45.72,76.67 v43.81,76.67 | IC26.20 48.26,56.35 46.98,56.35 BYP26.1 45.72,56.35 v43.81,56.35 | BYP9.1 44.45,20.79 45.72,20.79 IC9.24 | BYP10.1 44.45,43.65 45.72,43.65 IC10.24 | BYP3.1 13.97,38.57 15.24,38.57 IC3.20 | BYP1.1 13.97,13.17 15.24,13.17 IC1.20 | BYP2.1 13.97,25.87 15.24,25.87 IC2.20 | BYP8.1 13.97,102.07 15.24,102.07 IC8.20 | BYP7.1 13.97,89.37 15.24,89.37 IC7.20 | BYP6.1 13.97,76.67 15.24,76.67 IC6.20 | BYP4.1 13.97,51.27 15.24,51.27 IC4.20 | BYP5.1 13.97,63.97 15.24,63.97 IC5.20 | v43.81,46.19 16.5,46.19 v15.87,46.82 | v48.89,58.89 51.43,58.89 52.07,59.52 57.78,59.52 58.41,60.16 60.96,60.16 61.59,60.8 SV9.11 | v196.21,79.21 191.76,79.21 R5.2 | 200.66,86.19 201.29,85.56 IC21.10 | 196.84,86.19 200.66,86.19 | 196.84,86.19 196.21,85.56 IC21.8 | 200.66,86.19 205.73,86.19 206.37,85.56 IC21.12 | 196.84,86.19 v175.89,86.19 | v179.7,89.37 176.53,89.37 BYP21.1 | v178.43,56.35 179.7,56.35 IC17.8 182.24,56.35 v186.05,56.35 | v198.75,61.43 197.48,61.43 IC17.35 194.94,61.43 v186.05,61.43 | v205.1,43.65 207.64,43.65 IC19.16 | v205.1,65.24 207.64,65.24 IC28.16 | v188.59,10.63 195.57,10.63 BYP18.1 | v206.37,23.33 189.22,23.33 v188.59,22.7 | v206.37,29.68 199.38,29.68 198.75,30.31 BYP19.1 | v205.1,63.97 197.48,63.97 IC17.36 194.94,63.97 v191.13,63.97 | IC24.24 89.53,103.34 90.16,103.97 93.97,103.97 94.61,103.34 IC24.22
  Bottom 0.508: BYP16.1 87.62,76.67 88.89,76.67 IC16.20 | v97.15,84.29 99.05,84.29 R14.2 100.32,84.29 v112.39,84.29 | 90.16,79.84 v89.53,80.48 | 90.16,79.84 99.05,79.84 v99.69,80.48 | v114.93,25.87 113.02,25.87 IC12.11 | v114.93,13.17 113.02,13.17 IC11.11 | v114.93,38.57 113.02,38.57 IC13.11 | v114.93,63.97 113.02,63.97 IC15.11 | v114.93,51.27 113.02,51.27 IC14.11 | IC23.27 139.69,81.75 138.42,81.75 IC23.28 137.16,81.75 135.88,81.75 BYP23.1 134.62,81.75 130.81,81.75 130.17,81.11 113.02,81.11 v112.39,81.75 | BYP22.1 135.88,61.43 137.16,61.43 IC22.28 137.79,62.7 138.42,63.34 142.23,63.34 142.87,62.7 IC22.26 | R12.2 179.06,10.63 180.34,10.63 R3.2 | v173.35,5.55 175.25,5.55 R9.2 | IC27.4 168.91,15.08 170.17,15.08 172.08,13.17 v173.35,13.17 174.62,13.17 IC27.10 177.16,13.17 v178.43,13.17 v188.59,13.17 | v172.08,36.66 v139.06,36.66 v133.98,36.66 | v172.08,23.33 v173.35,23.33 174.62,23.33 IC27.14 | v136.52,23.33 134.62,23.33 C10.1 | v135.25,33.49 138.42,33.49 IC20.16 | v48.89,80.48 70.48,80.48 71.11,79.84 90.16,79.84
VMA
  Top 0.254: IC18.9 207.64,8.09 210.18,8.09 210.18,20.79 211.45,22.06 211.45,65.88 210.18,67.14 210.18,100.8 208.28,102.7 187.32,102.7 187.32,75.4 184.78,72.86 184.78,66.51 182.24,63.97 IC17.5

## Text on the board
tPlace: + | +